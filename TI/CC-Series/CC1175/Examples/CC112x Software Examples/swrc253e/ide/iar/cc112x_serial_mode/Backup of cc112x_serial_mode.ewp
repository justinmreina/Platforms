# IAR project Backup of cc112x_serial_mode.ewp, settings and files
configuration synchronous mode - RX (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\source\components\targets\trxeb_msp430f5438a; ..\..\..\source\components\bsp\trxeb_msp5438a\drivers\source; ..\..\..\source\components\targets\interface; ..\..\..\source\components\common; ..\..\..\source\components\common\msp430; ..\..\..\source\components\devices\cc112x; ..\..\..\source\components\devices\lcd_dogm128_6
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration synchronous mode - TX (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
configuration transparent mode - TX (MSP430, debug)
  as the first configuration, except:
  ICC430.CCOptLevel: 0
configuration transparent mode - RX (MSP430, debug)
  as the first configuration, except:
  ICC430.CCOptLevel: 0
configuration transparent mode - RX - oversampling(3) (MSP430, debug)
  as the first configuration, except:
  ICC430.CCOptLevel: 0
  group (top)
    ../../../source/apps/cc112x_serial_mode/: cc112x_serial_mode_reg_config.h cc112x_synchronous_serial_mode_rx.c cc112x_synchronous_serial_mode_tx.c cc112x_transparent_serial_mode_rx.c cc112x_transparent_serial_mode_rx_oversampling.c cc112x_transparent_serial_mode_tx.c
  group bsp
    ../../../source/components/bsp/trxeb_msp5438a/drivers/source/: als_trxeb.c bsp.c bsp_key.c bsp_led.c bsp_uart.c flash_trxeb.c io_pin_int.c lcd_dogm128_6.c lcd_dogm128_6_alphabet.c lcd_trxeb.c
  group hal
    ../../../source/components/devices/cc112x/: cc112x_spi.c
    ../../../source/components/targets/trxeb_msp430f5438a/: hal_spi_rf_trxeb.c
