<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cc112x_easy_link.ewp</path>
  </project>
  <batchBuild/>
</workspace>


