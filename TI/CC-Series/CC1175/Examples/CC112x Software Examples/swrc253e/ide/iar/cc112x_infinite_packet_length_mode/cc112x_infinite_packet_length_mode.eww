<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cc112x_infinite_packet_length_mode.ewp</path>
  </project>
  <batchBuild/>
</workspace>


