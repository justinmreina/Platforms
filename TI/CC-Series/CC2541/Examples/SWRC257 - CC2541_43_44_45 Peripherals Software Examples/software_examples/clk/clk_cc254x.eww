<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\clk_hs_rcosc_cc254x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\clk_hs_xosc_cc254x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\clk_ls_xosc_cc254x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


