<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\wdt_timer_cc254x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\wdt_wd_cc254x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


