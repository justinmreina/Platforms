<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dma_man_trigger_cc254x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dma_prev_trigger_cc254x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


