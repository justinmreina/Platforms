<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\io_in_cc254x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\io_multi_in_out_cc254x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\io_out_cc254x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


