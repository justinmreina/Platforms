# IAR project ref_spi.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  group (top)
    ../: globals.h main.c spi.c spi.h
  group components
    ../components/: hal_types.h ioCC2541_jmr.h ioCC254x_bitdef.h
