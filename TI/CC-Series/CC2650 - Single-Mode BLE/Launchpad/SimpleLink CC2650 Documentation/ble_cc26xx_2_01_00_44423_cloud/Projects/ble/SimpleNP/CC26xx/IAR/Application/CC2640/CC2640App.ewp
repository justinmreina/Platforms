# IAR project CC2640App.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ICALL; xSNP_SBL_ENABLE; xPOWER_SAVING; HEAPMGR_SIZE=9300; xTI_DRIVERS_LCD_INCLUDED; xTI_DRIVERS_SPI_DMA_INCLUDED; CC2650_HOSTTESTAPP; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; NPI_USE_UART; CC26XX; ICALL_MAX_NUM_ENTITIES=8; ICALL_MAX_NUM_TASKS=4; MAX_NUM_BLE_CONNS=1; xSWO_DEBUG; NO_OSAL_SNV; HEAPMGR_METRICS; MAX_PDU_SIZE=251; MAX_NUM_PDU=6
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\..\..\..\..\..\..\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Components/npi/unified/inc; ../../../../../../../Components/npi/unified; ../../../../../../../Projects/ble/include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles/CC26xx; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Projects/ble/Profiles/DevInfo; ../../../../../../../Projects/ble/Profiles/SimpleProfile; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/host; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SNPAppFlashROM.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: SNPAppFlashROM.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\common\cc26xx\IAR\cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM SPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_ICALL; xSNP_SBL_ENABLE; POWER_SAVING; HEAPMGR_SIZE=9200; xTI_DRIVERS_LCD_INCLUDED; CC2650_HOSTTESTAPP; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; NPI_USE_SPI; CC26XX; ICALL_MAX_NUM_ENTITIES=8; ICALL_MAX_NUM_TASKS=4; MAX_NUM_BLE_CONNS=1; xSWO_DEBUG; NO_OSAL_SNV; HEAPMGR_METRICS; MAX_PDU_SIZE=251; MAX_NUM_PDU=6
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Components/npi/unified/inc; ../../../../../../../Components/npi/unified; ../../../../../../../Projects/ble/include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles/CC26xx; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Projects/ble/Profiles/DevInfo; ../../../../../../../Projects/ble/Profiles/SimpleProfile/CC26xx; ../../../../../../../Projects/ble/Profiles/SimpleProfile; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/host; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  OBJCOPY.OOCOutputFile: SNPAppFlashROM_SPI.hex
  ILINK.IlinkOutputFile: SNPAppFlashROM_SPI.out
  ILINK.IlinkConfigDefines: RTOS_ROM=1
configuration FlashROMDbg (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_ICALL; SNP_SBL_ENABLE; POWER_SAVING; HEAPMGR_SIZE=9140; xTI_DRIVERS_LCD_INCLUDED; xTI_DRIVERS_SPI_DMA_INCLUDED; CC2650_HOSTTESTAPP; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; NPI_USE_UART; CC26XX; ICALL_MAX_NUM_ENTITIES=8; ICALL_MAX_NUM_TASKS=4; MAX_NUM_BLE_CONNS=1; xSWO_DEBUG; NO_OSAL_SNV; HEAPMGR_METRICS; MAX_PDU_SIZE=251; MAX_NUM_PDU=6
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Components/npi/unified/inc; ../../../../../../../Components/npi/unified; ../../../../../../../Projects/ble/include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles/CC26xx; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Projects/ble/Profiles/DevInfo; ../../../../../../../Projects/ble/Profiles/SimpleProfile; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/host; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  OBJCOPY.OOCOutputFile: SNPAppFlashROMDbg.hex
  ILINK.IlinkOutputFile: SNPAppFlashROMDbg.out
  ILINK.IlinkConfigDefines: RTOS_ROM=1
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  group Application
    ../../../Source/Application/: simpleNP.c simpleNP.h simpleNP_DEV.c simpleNP_DEV.h simpleNP_GAP.c simpleNP_GAP.h simpleNP_GATT.c simpleNP_GATT.h simpleNP_UUID.c simpleNP_UUID.h simpleNP_vendor_UUID.h
    ../../../../../common/cc26xx/: util.c util.h
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UART
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: UART.c UART.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/uart/: UARTCC26XX.c UARTCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    ../../../../../../../Components/applib/heap/: heapmgr.h
    ../../../../../../../Components/icall/ports/tirtos/: ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../../../../Components/icall/include/: ICall.h
    ../../../../../../../Components/hal/target/CC2650TIRTOS/: ICallAddrs.h
  group ICallBLE
    ../../../../../ICall/Application/: bleUserConfig.c ICallBleAPI.c
    ../../../../../ICall/Include/: bleUserConfig.h ICallBleAPIMSG.h
  group NPI/Transport
    ../../../../../../../Components/npi/unified/: npi_tl.c
    ../../../../../../../Components/npi/unified/inc/: npi_tl.h
  group NPI/Transport/SPI
    ../../../../../../../Components/npi/unified/: npi_tl_spi.c
    ../../../../../../../Components/npi/unified/inc/: npi_tl_spi.h
  group NPI/Transport/UART
    ../../../../../../../Components/npi/unified/: npi_tl_uart.c
    ../../../../../../../Components/npi/unified/inc/: npi_tl_uart.h
  group NPI/U_NPI
    ../../../../../../../Components/npi/unified/inc/: npi_data.h npi_task.h npi_util.h
    ../../../../../../../Components/npi/unified/: npi_task.c npi_util.c
  group PROFILES
    ../../../../../Profiles/DevInfo/CC26xx/: devinfoservice.c
    ../../../../../Profiles/DevInfo/: devinfoservice.h
    ../../../../../Include/: gatt_profile_uuid.h
    ../../../../../../../Components/ble/host/: gatt_uuid.c
    ../../../../../../../Components/ble/include/: gatt_uuid.h
    ../../../../../Profiles/GATT/: gattservapp_util.c
    ../../../../../Profiles/Roles/CC26xx/: peripheral.c peripheral.h
  group Startup
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SRF06EB/: Board.c
    ../../Config/: ccfg_sbl.c
    ../../../Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg IAR-Boundary.bdef IAR-Boundary.xcl
    ../../../../../common/cc26xx/IAR/: cc26xx_ble_app.icf
