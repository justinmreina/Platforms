<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NpulseWave_TIM_Sync.ewp</path>
  </project>
  <batchBuild />
</workspace>
