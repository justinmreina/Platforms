<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CycleByCycle_Regulation_BKP.ewp</path>
  </project>
  <batchBuild />
</workspace>
