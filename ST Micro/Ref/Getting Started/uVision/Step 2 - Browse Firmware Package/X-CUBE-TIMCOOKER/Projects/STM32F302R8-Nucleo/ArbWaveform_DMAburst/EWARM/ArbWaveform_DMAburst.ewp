# IAR project ArbWaveform_DMAburst.ewp, settings and files
configuration ArbWaveform_DMAburst Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302x8 ST STM32F302x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302x8
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: ArbWaveform_DMAburst Configuration.out
  ILINK.IlinkIcfFile: stm32f302x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f302x8.s
  group Application/User
    ../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
