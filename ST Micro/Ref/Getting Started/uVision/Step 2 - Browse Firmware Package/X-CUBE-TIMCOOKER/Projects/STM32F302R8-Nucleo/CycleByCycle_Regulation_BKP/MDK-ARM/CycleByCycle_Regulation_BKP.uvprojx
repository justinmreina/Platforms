# Keil uVision project CycleByCycle_Regulation_BKP.uvprojx, settings and files
target CycleByCycle_Regulation_BKP Configuration (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: CycleByCycle_Regulation_BKP
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8
  c misc: --C99
  c include: ../Inc;..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f302x8.s
  group Doc
    ../: Readme.txt
  group Application/User
    ../Src/: stm32f3xx_it.c main.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_ppp.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_fmc.c
  group Drivers/CMSIS
    ../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
