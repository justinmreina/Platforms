# Keil uVision project Project.uvproj, settings and files
target STM32L0xx_DISCO (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L053C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: STM32L0xx_DISCO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32L0538-Discovery;..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/COMPONENT
    ../../../../../Drivers/BSP/Components/gde021a1/: gde021a1.c
  group Drivers/BSP/STM32L0xx_DISCO
    ../../../../../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c stm32l0538_discovery_epd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
